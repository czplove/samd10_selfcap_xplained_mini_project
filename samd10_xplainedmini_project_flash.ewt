<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>asf</name>
    <group>
      <name>common</name>
      <group>
        <name>boards</name>
        <file>
          <name>$PROJ_DIR$\asf\common\boards\board.h</name>
        </file>
      </group>
      <group>
        <name>utils</name>
        <group>
          <name>interrupt</name>
          <file>
            <name>$PROJ_DIR$\asf\common\utils\interrupt\interrupt_sam_nvic.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\common\utils\interrupt\interrupt_sam_nvic.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\asf\common\utils\interrupt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\asf\common\utils\parts.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>common2</name>
      <group>
        <name>services</name>
        <group>
          <name>delay</name>
          <group>
            <name>sam0</name>
            <file>
              <name>$PROJ_DIR$\asf\common2\services\delay\sam0\systick_counter.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\common2\services\delay\sam0\systick_counter.h</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\asf\common2\services\delay\delay.h</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>sam0</name>
      <group>
        <name>boards</name>
        <group>
          <name>samd10_xplained_mini</name>
          <file>
            <name>$PROJ_DIR$\asf\sam0\boards\samd10_xplained_mini\board_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\boards\samd10_xplained_mini\samd10_xplained_mini.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>drivers</name>
        <group>
          <name>port</name>
          <group>
            <name>quick_start</name>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\port\quick_start\qs_port_basic.h</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\port\port.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\port\port.h</name>
          </file>
        </group>
        <group>
          <name>rtc</name>
          <group>
            <name>rtc_sam_d_r</name>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\rtc\rtc_sam_d_r\rtc_count.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\rtc\rtc_sam_d_r\rtc_count_interrupt.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\rtc\rtc_count.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\rtc\rtc_count_interrupt.h</name>
          </file>
        </group>
        <group>
          <name>sercom</name>
          <group>
            <name>usart</name>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\sercom\usart\usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\sercom\usart\usart.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\sercom\usart\usart_interrupt.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\sercom\usart\usart_interrupt.h</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\sercom\sercom.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\sercom\sercom.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\sercom\sercom_interrupt.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\sercom\sercom_interrupt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\sercom\sercom_pinout.h</name>
          </file>
        </group>
        <group>
          <name>system</name>
          <group>
            <name>clock</name>
            <group>
              <name>clock_samd10_d11</name>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\clock\clock_samd10_d11\clock.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\clock\clock_samd10_d11\clock_config_check.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\clock\clock_samd10_d11\clock_feature.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\clock\clock_samd10_d11\gclk.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\system\clock\clock.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\system\clock\gclk.h</name>
            </file>
          </group>
          <group>
            <name>interrupt</name>
            <group>
              <name>system_interrupt_samd10_d11</name>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\interrupt\system_interrupt_samd10_d11\system_interrupt_features.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\system\interrupt\system_interrupt.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\system\interrupt\system_interrupt.h</name>
            </file>
          </group>
          <group>
            <name>pinmux</name>
            <group>
              <name>quick_start</name>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\pinmux\quick_start\qs_pinmux_basic.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\system\pinmux\pinmux.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\system\pinmux\pinmux.h</name>
            </file>
          </group>
          <group>
            <name>power</name>
            <group>
              <name>power_sam_d_r</name>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\power\power_sam_d_r\power.h</name>
              </file>
            </group>
          </group>
          <group>
            <name>reset</name>
            <group>
              <name>reset_sam_d_r</name>
              <file>
                <name>$PROJ_DIR$\asf\sam0\drivers\system\reset\reset_sam_d_r\reset.h</name>
              </file>
            </group>
          </group>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\system\system.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\system\system.h</name>
          </file>
        </group>
        <group>
          <name>tc</name>
          <group>
            <name>tc_sam_d_r</name>
            <file>
              <name>$PROJ_DIR$\asf\sam0\drivers\tc\tc_sam_d_r\tc.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\tc\tc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\tc\tc_interrupt.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\drivers\tc\tc_interrupt.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>utils</name>
        <group>
          <name>cmsis</name>
          <group>
            <name>samd10</name>
            <group>
              <name>include</name>
              <group>
                <name>component</name>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\ac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\adc.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\dac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\dmac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\dsu.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\eic.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\evsys.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\gclk.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\mtb.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\nvmctrl.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\pac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\pm.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\port.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\rtc.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\sercom.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\sysctrl.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\tc.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\tcc.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\usb.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\component\wdt.h</name>
                </file>
              </group>
              <group>
                <name>instance</name>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\ac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\adc.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\dac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\dmac.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\dsu.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\eic.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\evsys.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\gclk.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\mtb.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\nvmctrl.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\pac0.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\pac1.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\pac2.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\pm.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\port.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\rtc.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\sercom0.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\sercom1.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\sercom2.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\sysctrl.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\tc1.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\tc2.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\tcc0.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\usb.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\instance\wdt.h</name>
                </file>
              </group>
              <group>
                <name>pio</name>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10c12a.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10c13a.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10c14a.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10d12am.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10d12as.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10d13am.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10d13as.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10d14am.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\pio\samd10d14as.h</name>
                </file>
              </group>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10c12a.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10c13a.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10c14a.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10d12am.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10d12as.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10d13am.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10d13as.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10d14am.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\include\samd10d14as.h</name>
              </file>
            </group>
            <group>
              <name>source</name>
              <group>
                <name>iar</name>
                <file>
                  <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\source\iar\startup_samd10.c</name>
                </file>
              </group>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\source\system_samd10.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\asf\sam0\utils\cmsis\samd10\source\system_samd10.h</name>
              </file>
            </group>
          </group>
        </group>
        <group>
          <name>header_files</name>
          <file>
            <name>$PROJ_DIR$\asf\sam0\utils\header_files\io.h</name>
          </file>
        </group>
        <group>
          <name>preprocessor</name>
          <file>
            <name>$PROJ_DIR$\asf\sam0\utils\preprocessor\mrecursion.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\utils\preprocessor\mrepeat.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\utils\preprocessor\preprocessor.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\utils\preprocessor\stringz.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\asf\sam0\utils\preprocessor\tpaste.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\asf\sam0\utils\compiler.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\asf\sam0\utils\status_codes.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>conf</name>
    <file>
      <name>$PROJ_DIR$\conf\conf_board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\conf\conf_clocks.h</name>
    </file>
  </group>
  <group>
    <name>QTouch</name>
    <file>
      <name>$PROJ_DIR$\qtouch\libsamd10_qtouch_iar.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\qtouch\touch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\qtouch\touch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\qtouch\touch_api_ptc.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\asf.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


