# IAR project samd10_xplainedmini_project_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD10C14A Atmel ATSAMD10C14A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; __ATSAMD10D14AM__; RTC_COUNT_ASYNC=true; TC_ASYNC=true; BOARD=SAMD10_XPLAINED_MINI; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMD10D14AM__
  ICCARM.CCDiagSuppress: Pe188,Pe186
  ICCARM.CCIncludePath2: asf\sam0\drivers\tc\tc_sam_d_r; asf\sam0\drivers\system\interrupt\system_interrupt_samd10_d11; asf\sam0\utils; asf\sam0\boards\samd10_xplained_mini; asf\sam0\utils\header_files; asf\sam0\utils\cmsis\samd10\source; asf\sam0\drivers\tc; ..\..; asf\sam0\drivers\system\reset; asf\sam0\drivers\system\power; asf\sam0\utils\preprocessor; asf\sam0\drivers\system\clock; asf\common2\services\delay\sam0; asf\sam0\boards; asf\sam0\drivers\system; asf\sam0\drivers\system\pinmux; asf\common\boards; asf\sam0\drivers\system\reset\reset_sam_d_r; asf\common\utils; asf\sam0\drivers\rtc; asf\sam0\utils\cmsis\samd10\include; asf\sam0\drivers\system\interrupt; conf; asf\sam0\drivers\system\clock\clock_samd10_d11; asf\sam0\drivers\rtc\rtc_sam_d_r; asf\sam0\drivers\port; qtouch; asf\sam0\drivers\system\power\power_sam_d_r; asf\common2\services\delay; .; asf\thirdparty\CMSIS\Include; asf\sam0\drivers\sercom; asf\sam0\drivers\sercom\usart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: SYSTICK_MODE; __ATSAMD10D14AM__; RTC_COUNT_ASYNC=true; TC_ASYNC=true; BOARD=SAMD10_XPLAINED_MINI; ARM_MATH_CM0PLUS=true; __SAMD10D14AM__
  AARM.AUserIncludes: asf\sam0\drivers\tc\tc_sam_d_r; asf\sam0\drivers\system\interrupt\system_interrupt_samd10_d11; asf\sam0\utils; asf\sam0\boards\samd10_xplained_mini; asf\sam0\utils\header_files; asf\sam0\utils\cmsis\samd10\source; asf\sam0\drivers\tc; ..\..; asf\sam0\drivers\system\reset; asf\sam0\drivers\system\power; asf\sam0\utils\preprocessor; asf\sam0\drivers\system\clock; asf\common2\services\delay\sam0; asf\sam0\boards; asf\sam0\drivers\system; asf\sam0\drivers\system\pinmux; asf\common\boards; asf\sam0\drivers\system\reset\reset_sam_d_r; asf\common\utils; asf\sam0\drivers\rtc; asf\sam0\utils\cmsis\samd10\include; asf\sam0\drivers\system\interrupt; conf; asf\sam0\drivers\system\clock\clock_samd10_d11; asf\sam0\drivers\rtc\rtc_sam_d_r; asf\sam0\drivers\port; qtouch; asf\sam0\drivers\system\power\power_sam_d_r; asf\common2\services\delay; .
  OBJCOPY.OOCOutputFile: samd10_xplainedmini_project_flash.hex
  ILINK.IlinkOutputFile: samd10_xplainedmini_project_flash.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: asf.h main.c
  group asf/common/boards
    asf/common/boards/: board.h
  group asf/common/utils
    asf/common/utils/: interrupt.h parts.h
  group asf/common/utils/interrupt
    asf/common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group asf/common2/services/delay
    asf/common2/services/delay/: delay.h
  group asf/common2/services/delay/sam0
    asf/common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group asf/sam0/boards/samd10_xplained_mini
    asf/sam0/boards/samd10_xplained_mini/: board_init.c samd10_xplained_mini.h
  group asf/sam0/drivers/port
    asf/sam0/drivers/port/: port.c port.h
  group asf/sam0/drivers/port/quick_start
    asf/sam0/drivers/port/quick_start/: qs_port_basic.h
  group asf/sam0/drivers/rtc
    asf/sam0/drivers/rtc/: rtc_count.h rtc_count_interrupt.h
  group asf/sam0/drivers/rtc/rtc_sam_d_r
    asf/sam0/drivers/rtc/rtc_sam_d_r/: rtc_count.c rtc_count_interrupt.c
  group asf/sam0/drivers/sercom
    asf/sam0/drivers/sercom/: sercom.c sercom.h sercom_interrupt.c sercom_interrupt.h sercom_pinout.h
  group asf/sam0/drivers/sercom/usart
    asf/sam0/drivers/sercom/usart/: usart.c usart.h usart_interrupt.c usart_interrupt.h
  group asf/sam0/drivers/system
    asf/sam0/drivers/system/: system.c system.h
  group asf/sam0/drivers/system/clock
    asf/sam0/drivers/system/clock/: clock.h gclk.h
  group asf/sam0/drivers/system/clock/clock_samd10_d11
    asf/sam0/drivers/system/clock/clock_samd10_d11/: clock.c clock_config_check.h clock_feature.h gclk.c
  group asf/sam0/drivers/system/interrupt
    asf/sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group asf/sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    asf/sam0/drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group asf/sam0/drivers/system/pinmux
    asf/sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group asf/sam0/drivers/system/pinmux/quick_start
    asf/sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group asf/sam0/drivers/system/power/power_sam_d_r
    asf/sam0/drivers/system/power/power_sam_d_r/: power.h
  group asf/sam0/drivers/system/reset/reset_sam_d_r
    asf/sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group asf/sam0/drivers/tc
    asf/sam0/drivers/tc/: tc.h tc_interrupt.c tc_interrupt.h
  group asf/sam0/drivers/tc/tc_sam_d_r
    asf/sam0/drivers/tc/tc_sam_d_r/: tc.c
  group asf/sam0/utils
    asf/sam0/utils/: compiler.h status_codes.h
  group asf/sam0/utils/cmsis/samd10/include
    asf/sam0/utils/cmsis/samd10/include/: samd10.h samd10c12a.h samd10c13a.h samd10c14a.h samd10d12am.h samd10d12as.h samd10d13am.h samd10d13as.h samd10d14am.h samd10d14as.h
  group asf/sam0/utils/cmsis/samd10/include/component
    asf/sam0/utils/cmsis/samd10/include/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h mtb.h nvmctrl.h pac.h pm.h port.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
  group asf/sam0/utils/cmsis/samd10/include/instance
    asf/sam0/utils/cmsis/samd10/include/instance/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h mtb.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h rtc.h sercom0.h sercom1.h sercom2.h sysctrl.h tc1.h tc2.h tcc0.h usb.h wdt.h
  group asf/sam0/utils/cmsis/samd10/include/pio
    asf/sam0/utils/cmsis/samd10/include/pio/: samd10c12a.h samd10c13a.h samd10c14a.h samd10d12am.h samd10d12as.h samd10d13am.h samd10d13as.h samd10d14am.h samd10d14as.h
  group asf/sam0/utils/cmsis/samd10/source
    asf/sam0/utils/cmsis/samd10/source/: system_samd10.c system_samd10.h
  group asf/sam0/utils/cmsis/samd10/source/iar
    asf/sam0/utils/cmsis/samd10/source/iar/: startup_samd10.c
  group asf/sam0/utils/header_files
    asf/sam0/utils/header_files/: io.h
  group asf/sam0/utils/preprocessor
    asf/sam0/utils/preprocessor/: mrecursion.h mrepeat.h preprocessor.h stringz.h tpaste.h
  group conf
    conf/: conf_board.h conf_clocks.h
  group QTouch
    qtouch/: libsamd10_qtouch_iar.a touch.c touch.h touch_api_ptc.h
